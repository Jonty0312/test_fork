# Keil uVision project test15c.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: test15c +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: main15.c oled.c smoke.c uart.c config.h oledfont.h STC15Fxxxx.H iic.c STC_BH1750.c GPIO.c delay.c dht11.c onewire.c
